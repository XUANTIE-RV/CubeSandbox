# linux-cube-guest 7.2: the microVM *guest* kernel payload matching the
# upstream CubeSandbox guest config. NOT the machine boot kernel.
#
# Grounding:
#  * Makefile `guest-kernel` (MK L676-693) + scripts/build-kernel.sh: out-of-tree
#    kbuild, ARCH=riscv, CROSS_COMPILE=riscv64-linux-gnu-, config from
#    configs/kernel-oc9.riscv64.config, image target `Image`, final artifact
#    copied to <out>/vmlinux (build-kernel.sh L45,L73-82; shim expects
#    .../cube-kernel-scf/vmlinux, config-cube.toml L13).
#  * configs/kernel-oc9.riscv64.config header: "Linux/riscv 7.2.0-rc7" (L3),
#    generated with clang 17.0.6 (L5-12: CONFIG_CC_IS_CLANG=y,
#    CONFIG_GCC_VERSION=0, CONFIG_CLANG_VERSION=170006) and even in-kernel Rust
#    1.89 (L14-16 CONFIG_RUSTC_VERSION=108900). TODO(verify): exact kernel git
#    repo/tag — Makefile takes KERNEL_SRC from the environment, so provenance is
#    a deployment choice (torvalds/linux v7.2-rc7 is the natural match).
#
# SELECTION (DESIGN.md §5.1): 7.2 is the upstream-parity but NEWER/clang-flavoured
# guest kernel; 6.6 (linux-cube-guest_6.6.bb, reusing the in-tree XuanTie kernel)
# is the bring-up/stable default. This recipe carries DEFAULT_PREFERENCE = "-1"
# so 6.6 wins unless the integrator sets PREFERRED_VERSION_linux-cube-guest="7.2".
#
# Style reference: meta-xuantie/recipes-kernel/linux/linux-xuantie_6.6.y.bb
# (inherit kernel, git SRC_URI, KCONFIG_MODE="--alldefconfig").

SUMMARY = "CubeSandbox microVM guest kernel 7.2 (riscv64, Image deployed as vmlinux)"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
# TODO(verify): LIC_FILES_CHKSUM against the actual 7.2 kernel source tree.

inherit kernel

# Prefer 6.6 for bring-up; 7.2 is opt-in (see SELECTION note above).
DEFAULT_PREFERENCE = "-1"

# Out-of-tree guest-kernel fixes, canonical copies in configs/patches/ (shared
# with the `make guest-kernel KERNEL_SRC=<tree>` flow, which applies them with
# `patch -p1`). do_patch applies the file://*.patch entries below; the
# FILESEXTRAPATHS prepend lets bitbake find them in configs/patches so there is a
# single copy of each patch (no duplication into this recipe's files/ dir).
#  * riscv64-dax-zeropage-folio.patch  -- fs/dax: test the zero/empty entry
#    before dax_to_folio(); without it the first DAX write fault dereferences
#    vmemmap[0] and panics on riscv (RAM does not start at pfn 0). Required for
#    the DAX guest rootfs / pmem.
#  * riscv64-kvm-zeropage-dirtylog.patch -- KVM: riscv: never promote the shared
#    zero page to writable in the dirty-log write fault fast path
#    (kvm_riscv_mmu_dirty_log_write_fault_fast, upstream Message-Id
#    20260517153427.94889-6-tjytimi@163.com). Without it an L2 under nested KVM
#    at -smp>1 with dirty logging writes through a read-only ZERO_PAGE G-stage
#    mapping into the host empty_zero_page, corrupting every fresh anon page
#    host-wide (silent; persists until reboot). Required for multi-vCPU
#    snapshot/restore.
# NOTE: FILESEXTRAPATHS reaches into the repo root (../../../../configs/patches);
# valid only while this layer lives at <repo>/yocto-integration/meta-cubesandbox.
FILESEXTRAPATHS:prepend := "${THISDIR}/../../../../configs/patches:"

# TODO(verify): replace with the real 7.2 kernel repo/tag once identified.
SRC_URI = " \
    git://github.com/torvalds/linux.git;protocol=https;branch=master;destsuffix=git \
    file://cube-guest-riscv64-defconfig \
    file://riscv64-dax-zeropage-folio.patch \
    file://riscv64-kvm-zeropage-dirtylog.patch \
"
SRCREV = "${AUTOREV}"
# AUTOREV is a placeholder — a real integration MUST pin SRCREV to v7.2-rc7 (both
# patches were generated against v7.2; a moving master may need them rebased).

LINUX_VERSION = "7.2"
LINUX_VERSION_EXTENSION = "-cube-guest"
PV = "${LINUX_VERSION}${LINUX_VERSION_EXTENSION}+git${SRCPV}"

S = "${WORKDIR}/git"

KCONFIG_MODE = "--alldefconfig"

do_configure() {
	# build-kernel.sh: install the config as .config, then olddefconfig.
	install -m 0644 ${WORKDIR}/cube-guest-riscv64-defconfig ${B}/.config
	oe_runmake_call -C ${S} O=${B} olddefconfig
	# The config was generated by clang 17 with in-kernel Rust 1.89. When
	# building with the xuantie GCC, olddefconfig drops the compiler-stamp
	# symbols (CONFIG_CC_IS_CLANG, CONFIG_GCC_VERSION, CONFIG_CLANG_VERSION,
	# CONFIG_RUSTC_VERSION, ...) automatically. Audit clang-only options that
	# olddefconfig will NOT translate: CONFIG_LTO_CLANG*, CONFIG_SHADOW_CALL_
	# STACK, CONFIG_CFI_CLANG (all currently "# not set" in the config, so no
	# action needed today) and CONFIG_RUST/CONFIG_HAVE_RUST (L14,L641 — disable
	# CONFIG_RUST unless a matching rustc-for-kernel is wired up).
	# TODO(verify): building a clang-17-generated config with GCC 13 may warn
	# on -Werror paths; consider building 7.2 with TOOLCHAIN=clang (the tree
	# already supports toolchain-clang overrides in linux-xuantie_6.6.y.bb
	# L102-127 and ships meta-clang, currently clang 15 per clang.inc L7-8).
}

KERNEL_IMAGETYPE = "Image"
# Deploy Image AS `vmlinux` — the name the shim/deploy scripts expect for
# cube-kernel-scf/vmlinux (scripts/build-kernel.sh L73-82 normalizes the raw
# Image target to vmlinux for riscv64). kernel.bbclass already deploys the
# Image under KERNEL_IMAGETYPE; we add a `vmlinux` alias so BOTH the 6.6 and
# 7.2 recipes emit the same artifact name the runtime consumes.
do_deploy:append() {
	install -m 0644 ${B}/arch/${ARCH}/boot/Image ${DEPLOYDIR}/vmlinux
}

# Keep out of the machine kernel provider chain. kernel.bbclass unconditionally
# does `PROVIDES += "virtual/kernel"` (classes-recipe/kernel.bbclass L14), so we
# cannot un-provide it; instead we (a) never become PREFERRED_PROVIDER
# (meta-xuantie sets PREFERRED_PROVIDER_virtual/kernel = "linux-xuantie",
# xuantie-base.inc L25) and (b) use a distinct KERNEL_PACKAGE_NAME so package
# names never collide with the machine kernel.
KERNEL_PACKAGE_NAME = "cube-guest-kernel"
KERNEL_VERSION_SANITY_SKIP = "1"

COMPATIBLE_HOST = "(riscv64).*-linux"
